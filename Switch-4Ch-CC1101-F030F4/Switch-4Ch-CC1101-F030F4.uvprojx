# Keil uVision project Switch-4Ch-CC1101-F030F4.uvprojx, settings and files
target Switch-4Ch-CC1101-F030F4 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Switch-1Ware-4Ch-CC1101-F030F4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: .\Inc;..\DeviceLib-F030\Inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Main
    ./Src/: CC1101.c F030f4_Peripheral.c main.c rf_cmd_exec.c xdebug.c one_wire.c
    ../DeviceLib-F030/Src/: config.c rf_cmd.c timestamp.c xprintf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0
