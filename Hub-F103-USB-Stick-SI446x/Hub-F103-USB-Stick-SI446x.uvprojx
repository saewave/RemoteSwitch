# Keil uVision project Hub-F103-USB-Stick-SI446x.uvprojx, settings and files
target Hub-F103-USB-Stick-SI446x (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hub-F103-USB-Stick-SI446x +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;.\Lib\USB-CDC\Inc
  memory RVCT4: ROM 0x8000400 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./Src/: at_processor.c SI446x.c F103RE_Peripheral.c lib.c main.c rf_device.c rf_processor.c timestamp.c xdebug.c core.c
    ./Lib/USB-CDC/Src/: usblib.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
