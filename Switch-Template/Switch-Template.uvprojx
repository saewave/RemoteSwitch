# Keil uVision project Switch-Template.uvprojx, settings and files
target Switch-Template (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Switch-Template +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F030x4
  c misc: --C99
  c include: .\Inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Source
    ./Src/: main.c F030f4_Peripheral.c xprintf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0
