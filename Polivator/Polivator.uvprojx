# Keil uVision project Polivator.uvprojx, settings and files
target Polivator (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Polivator +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;..\DeviceLib-F030\Inc
  memory RVCT4: ROM 0x8000400 size 0x7800
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  scatter file: .\Objects\Polivator.sct
  group Code
    ./Src/: main.c core.c SI446x.c rf_cmd_exec.c xdebug.c F030C8_Peripheral.c
    ../DeviceLib-F030/Src/: config.c rf_cmd.c timestamp.c xprintf.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.5.0
