# Keil uVision project Switch-1Ware-4Ch-p.uvprojx, settings and files
target Switch-1Ware-4Ch-p (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Switch-1Ware-4Ch-p
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --C99
  c include: ..\Lib\Inc;.\Inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ../Lib/Src/: F030f4_Peripheral.c nRF24L01P.c rf_cmd.c timestamp.c xprintf.c
    ./Src/: main.c rf_cmd_exec.c config.c 1ware.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0
